<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\blargh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Timing\timing.ewp</path>
  </project>
  <batchBuild/>
</workspace>


